# Keil uVision project CAN_STD_FRAME_INT.uvprojx, settings and files
target CAN_STD_FRAME_INT (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: FM33LG04X FMSH
  pack: Keil.FM33LG0XX_DFP.0.0.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: CAN_STD_FRAME_INT +hex
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: FM33LG0XX,USE_FULL_ASSERT,MFANG
  c include: ..\Drivers\CMSIS\Inculde;..\Drivers\FM33LG0xx_FL_Driver\Inc;..\Drivers\CMSIS\Device\FM\FM33xx\Include;..\MF-config\Inc;..\Inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/FM/FM33xx/Source/Templates/arm/: startup_fm33lg0xx.s
  group Application/MF-Config
    ../MF-config/Src/: mf_config.c
    ../Src/: user_init.c can.c
  group Application/User
    ../Src/: main.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/FM/FM33xx/Source/: system_fm33lg0xx.c
  group Drivers/FM33LG0xx_FL_Driver
    ../Drivers/FM33LG0xx_FL_Driver/Src/: fm33lg0xx_fl_adc.c fm33lg0xx_fl_aes.c fm33lg0xx_fl_atim.c fm33lg0xx_fl_bstim32.c fm33lg0xx_fl_bstim16.c fm33lg0xx_fl_can.c fm33lg0xx_fl_comp.c fm33lg0xx_fl_crc.c fm33lg0xx_fl_dma.c fm33lg0xx_fl_dac.c fm33lg0xx_fl_flash.c fm33lg0xx_fl_gpio.c fm33lg0xx_fl_gptim.c fm33lg0xx_fl_divas.c fm33lg0xx_fl_i2c.c fm33lg0xx_fl_iwdt.c fm33lg0xx_fl_lptim32.c fm33lg0xx_fl_lptim16.c fm33lg0xx_fl_lpuart.c fm33lg0xx_fl_opa.c fm33lg0xx_fl_pmu.c fm33lg0xx_fl_cmu.c fm33lg0xx_fl_rng.c fm33lg0xx_fl_rtca.c fm33lg0xx_fl_rtcb.c fm33lg0xx_fl_spi.c fm33lg0xx_fl_svd.c fm33lg0xx_fl_u7816.c fm33lg0xx_fl_uart.c fm33lg0xx_fl_wwdt.c fm33lg0xx_fl_pgl.c fm33lg0xx_fl_vao.c fm33lg0xx_fl_lcd.c fm33lg0xx_fl_exti.c fm33lg0xx_fl.c
