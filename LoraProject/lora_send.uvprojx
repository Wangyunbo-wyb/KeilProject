# Keil uVision project lora_send.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: lora_send +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\RTE\_Target_1;.\RTE\Device\STM32F103ZE;.\User;.\lora;.\System;.\usart;.\Motor
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/: main.c
  group System
    ./System/: Delay.c Delay.h sys.c sys.h timer.c timer.h
  group lora
    ./lora/: lora_app.c lora_app.h
  group usart
    ./usart/: usart1.c usart1.h usart3.c usart3.h
  group Motor
    ./Motor/: 28byj_48.c 28byj_48.h
  group Hardware
    ../stm32Project/9-4 串口收发文本数据包/Hardware/: OLED.c OLED.h OLED_Font.h
software components: CMSIS:CORE 5.1.2, Device:Startup 1.0.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
